require python-jsonref.inc