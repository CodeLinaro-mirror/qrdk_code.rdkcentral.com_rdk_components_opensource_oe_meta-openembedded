# Copyright (c) 2013 LG Electronics, Inc.

require ${BPN}.inc
SRC_URI[md5sum] = "499abc66de7bb74a9117bda75e43ec4d"
SRC_URI[sha256sum] = "b19e23fc8e71f38aef7c059f44e59fcbff3bb2ce85baa8de81f1629b85f68fcf"
